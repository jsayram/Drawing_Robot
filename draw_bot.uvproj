# Keil uVision project draw_bot.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: draw_bot
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: motor_header.h system_clock.h startup_stm32l1xx_md.s stm32l1xx_constants.s draw_bot.c
